# Repository Oku-Dan/Mini_STSPIN32G4_3Phase_Motor_Driver_Board

## KiCad design Mini_STSPIN32G4_3Phase_Motor_Driver.kicad_pcb

Parts:
H1, H2, H3, H4: MountingHole; MountingHole_3mm

Parts:
C36, C38: 1u; C_0603_1608Metric
C37: 100n; C_0603_1608Metric
C39: 4.7n; C_0402_1005Metric
D5, D6, D7, D8: 1N5819WS; D_SOD-323
J1: Conn_01x06_Pin; JST_XA_S06B-XASK-1_1x06_P2.50mm_Horizontal
J2: USB_C_Receptacle_USB2.0_16P; USB_C_Receptacle_G-Switch_GT-USB-7010ASV
J3: Conn_02x07_Odd_Even; STDC14
R42: 0; R_0402_1005Metric
R43: 0; R_0402_1005Metric; not fitted
R44, R45: 5.1k; R_0402_1005Metric
R46, R47, R48, R49: 22; R_0402_1005Metric
R50, R51, R52, R53: 150; R_0402_1005Metric
R54: 1M; R_0402_1005Metric
R55: 100; R_0402_1005Metric
U2: L78L05_SOT89; SOT-89-3
U3: XC6206PxxxMR; SOT-23-3

Connections:
+3.3V: C38.1, R43.2, U3.2 (VO)
+3V3: J3.3; also elsewhere on the board
+5V_EXT: C37.1, R42.2, U2.1 (OUT)
+8V: C36.1, U2.3 (IN), U3.3 (VI); also elsewhere on the board
AIN1: R53.1; also elsewhere on the board
AIN2: R52.1; also elsewhere on the board
GNDS: C39.2, J1.2, J2.A1 (GND), J2.A12 (GND), J2.B1 (GND), J2.B12 (GND), J3.5, J3.7, R44.2, R45.2, R54.1, R55.1; also elsewhere on the board
MISO/A: D5.2 (A), R46.2, R50.2; also elsewhere on the board
MOSI/B: D6.2 (A), R47.2, R51.2; also elsewhere on the board
NRST: J3.12; also elsewhere on the board
NSS: D8.2 (A), R49.2, R53.2; also elsewhere on the board
unnamed: D5.1 (K), D6.1 (K), D7.1 (K), D8.1 (K), J1.1, R42.1, R43.1
unnamed: J1.3, R46.1
unnamed: J1.4, R47.1
unnamed: J1.5, R48.1
unnamed: J1.6, R49.1
unnamed: J2.A5 (CC1), R44.1
unnamed: J2.B5 (CC2), R45.1
unnamed: C39.1, J2.SH (SHIELD), R54.2
unnamed: J3.11, R55.2
SCK/X: D7.2 (A), R48.2, R52.2; also elsewhere on the board
SCL: R50.1; also elsewhere on the board
SDA: R51.1; also elsewhere on the board
SHUNT1-: C36.2, C37.2, C38.2, U2.2 (GND), U3.1 (GND); also elsewhere on the board
SWCLK: J3.6; also elsewhere on the board
SWDIO: J3.4; also elsewhere on the board
UART_RX: J3.13; also elsewhere on the board
UART_TX: J3.14; also elsewhere on the board
USB_DM: J2.A7 (D-), J2.B7 (D-); also elsewhere on the board
USB_DP: J2.A6 (D+), J2.B6 (D+); also elsewhere on the board

Notes on the sheet:
Encoder Type : SPI/ABX
CAN削除
PADに配線
5V Tolerant
Damping Resistance
※指示なきコンデンサは耐圧6.3V以上
ESD Protection
Max.22mA@3.3V
Vout=5V/Max.100mA/Max.350mW Max.100mA@Vin=8V Max.35mA@Vin=15V
I2C規格：吸い込み電流最大3mA (22Ω+150Ω) x 3mA = 0.53V < 0.3Vdd
Output
Collision Protection
Ir<100uA@75°C
DC Input
Vout=3.3V/Max.100mA/Max.250mW Max.50mA@Vin=8V Max.20mA@Vin=15V
Multi Port Encoder Input
USB
コネクタの極性に注意!!
※SMDは1608/0402を基本とする 但しBasic優先
SWD and Debug Serial
Encoder Type : Analog 2ch + I2C

Parts:
C1, C4, C9, C12: 1u; C_0603_1608Metric
C2, C3, C10, C11: 100n; C_0603_1608Metric
C5, C8: 100n 16V; C_0603_1608Metric
C6: 10u 16V; C_0603_1608Metric
C7: 1n; C_0603_1608Metric
C13, C14: 22n; C_0402_1005Metric
C15, C16: 100n; C_0402_1005Metric
D1: 1N5819WS; D_SOD-323; LCSC C14996
D2: KT-0805G; LED_0805_2012Metric
D3: KT-0603R; LED_0603_1608Metric
FB1: L_0805_2012Metric
FB2: GZ1608D601TF; L_0603_1608Metric
L1: SWPA4030S180MT; L_Sunlord_SWPA4030S; LCSC C96895; not fitted
NT1: NetTie_2; NetTie-2_SMD_Pad2.0mm
R1: 22; R_0603_1608Metric
R2: 2.2; R_0603_1608Metric
R3: 5.1k; R_0603_1608Metric
R4: 120; R_0603_1608Metric
R5: 100k 1%; R_0402_1005Metric
R6: 47k 1%; R_0402_1005Metric
R7: 1k 1%; R_0402_1005Metric
R8: 4.7k 1%; R_0402_1005Metric
R9, R11: 1k; R_0402_1005Metric
R10: 100k; R_0402_1005Metric
SW1, SW2: TS-1088-AR02016; SW_SPST_TS-1088-xR020
U1: STSPIN32G4; QFN-64-1EP_9x9mm_P0.5mm_EP4.1x4.1mm

Connections:
+3V3: C1.1, C2.1, FB2.2, R6.1, SW1.1, U1.1 (REG3V3/VDD), U1.2 (VBAT); also elsewhere on the board
+8V: C8.1, FB1.1, R3.1, U1.64 (REGIN); also elsewhere on the board
+VSW: C9.1, C10.1, R5.1, U1.61 (VM); also elsewhere on the board
AIN1: U1.9 (PC0); also elsewhere on the board
AIN2: U1.11 (PC2); also elsewhere on the board
BOOT1: U1.41 (BOOT1); also elsewhere on the board
BOOT2: U1.38 (BOOT2); also elsewhere on the board
BOOT3: U1.35 (BOOT3); also elsewhere on the board
GHS1: U1.43 (GHS1); also elsewhere on the board
GHS2: U1.40 (GHS2); also elsewhere on the board
GHS3: U1.37 (GHS3); also elsewhere on the board
GLS1: U1.29 (GLS1); also elsewhere on the board
GLS2: U1.30 (GLS2); also elsewhere on the board
GLS3: U1.31 (GLS3); also elsewhere on the board
GNDS: C1.2, C2.2, C3.2, C4.2, C11.2, C12.2, C13.2, C14.2, C15.2, C16.2, NT1.1, R7.2, R8.2, R11.2, SW2.2, U1.65 (VSS); also elsewhere on the board
LED: R4.1, U1.57 (PB6)
MISO/A: U1.55 (PB4); also elsewhere on the board
MOSI/B: U1.56 (PB5); also elsewhere on the board
NRST: C15.1, R9.2, U1.8 (PG10/NRST); also elsewhere on the board
NSS: U1.51 (PA15); also elsewhere on the board
unnamed: C3.1, C4.1, FB2.1, R1.1
unnamed: C7.1, R2.2
unnamed: D2.2 (A), R3.2
unnamed: D3.2 (A), R4.2
unnamed: R9.1, SW2.1
unnamed: R10.1, R11.1, SW1.2
OPAMP1_VINM: U1.25 (PB2/OPAMP3_VINM); also elsewhere on the board
OPAMP1_VINP: U1.23 (PB0/OPAMP3_VINP); also elsewhere on the board
OPAMP1_VOUT: U1.24 (PB1/OPAMP3_VOUT); also elsewhere on the board
OPAMP2_VINM: U1.18 (PA5/OPAMP2_VINM); also elsewhere on the board
OPAMP2_VINP: U1.20 (PA7/OPAMP2_VINP); also elsewhere on the board
OPAMP2_VOUT: U1.19 (PA6/OPAMP2_VOUT); also elsewhere on the board
OPAMP3_VINM: U1.16 (PA3/OPAMP1_VINM); also elsewhere on the board
OPAMP3_VINP: U1.14 (PA1/OPAMP1_VINP); also elsewhere on the board
OPAMP3_VOUT: U1.15 (PA2/OPAMP1_VOUT); also elsewhere on the board
OUT1: U1.42 (OUT1); also elsewhere on the board
OUT2: U1.39 (OUT2); also elsewhere on the board
OUT3: U1.36 (OUT3); also elsewhere on the board
SCK/X: U1.54 (PB3); also elsewhere on the board
SCL: U1.59 (PB8-BOOT0); also elsewhere on the board
SCREF: C14.1, R6.2, R8.1, U1.52 (SCREF)
SDA: U1.58 (PB7); also elsewhere on the board
SHUNT1-: C5.2, C6.2, C7.2, C8.2, C9.2, C10.2, D1.2 (A), D2.1 (K), D3.1 (K), NT1.2, U1.32 (PGND); also elsewhere on the board
SW: D1.1 (K), L1.1, R2.1, U1.62 (SW)
SWCLK: U1.50 (PA14/SWCLK-JTCK); also elsewhere on the board
SWDIO: U1.49 (PA13/SWDIO-JTMS); also elsewhere on the board
UART_RX: U1.46 (PA10); also elsewhere on the board
UART_TX: U1.45 (PA9); also elsewhere on the board
USB_DM: U1.47 (PA11/FDCAN1_RX); also elsewhere on the board
USB_DP: U1.48 (PA12/FDCAN1_TX); also elsewhere on the board
USER_SW: C16.1, R10.2, U1.13 (PA0)
VBUS: C13.1, R5.2, R7.1, U1.10 (PC1)
VCC: C5.1, C6.1, FB1.2, L1.2, U1.63 (VCC)
VDDA: C11.1, C12.1, R1.2, U1.26 (VREF+), U1.27 (VDDA); also elsewhere on the board

Notes on the sheet:
SCREF=0.3V
Tr=10ms
175~430mCd@5mA Vf=2.6~3.1V
100~120mCd@20mA Vf=1.9~2.2V
USER Indicator
+8V Indicator
8~12V Max.750mA
※SMDは1608/0402を基本とする 但しBasic優先
SCREF
※指示なきコンデンサは耐圧6.3V以上
600Ω@100MHz 0.45Ω/0.96uH
40V/Ave.1A
+VSW Monitor
Reset Switch
10mA≒60mCd
DCDC
User Switch
Analog Supply
15uH/Ave.1.1A
GND Isolation
1mA≒70mCd

Parts:
C17, C18, C19: 1u@8V; C_0603_1608Metric
C20, C21, C22, C23, C24, C25, C26, C27, C28, C29, C30, C31: 10u 50V; C_1206_3216Metric
C32: 220u; CP_Elec_10x10.5; not fitted
C33, C34, C35: 4.7p; C_0603_1608Metric; not fitted
D4: SMCJ33A; D_SMC
Q1, Q2, Q3, Q4, Q5, Q6: TMG60N04DF; Diodes_PowerDI3333-8
R12, R13, R14, R27, R28, R29: 1m 1% 2W; R_2512_6332Metric
R15, R16, R17, R21, R22, R23: 33; R_0603_1608Metric
R18, R19, R20, R24, R25, R26: 200k; R_0402_1005Metric
R30, R31, R32, R36, R37, R38: 47k 1%; R_0603_1608Metric
R33, R34, R35: 1.5k 1%; R_0603_1608Metric
R39, R40, R41: 1.5k/1%; R_0603_1608Metric

Connections:
+VSW: C32.1, D4.1 (K), R12.2; also elsewhere on the board
+VSW0: C20.1, C21.1, C22.1, C23.1, Q1.5 (D), R12.1, R13.2
+VSW1: C24.1, C25.1, C26.1, C27.1, Q2.5 (D), R13.1, R14.2
+VSW2: C28.1, C29.1, C30.1, C31.1, Q3.5 (D), R14.1
BOOT1: C17.1; also elsewhere on the board
BOOT2: C18.1; also elsewhere on the board
BOOT3: C19.1; also elsewhere on the board
GHS1: R15.1; also elsewhere on the board
GHS2: R16.1; also elsewhere on the board
GHS3: R17.1; also elsewhere on the board
GLS1: R21.1; also elsewhere on the board
GLS2: R22.1; also elsewhere on the board
GLS3: R23.1; also elsewhere on the board
GNDS: R36.2, R37.2, R38.2; also elsewhere on the board
unnamed: Q1.4 (G), R15.2, R18.1
unnamed: Q2.4 (G), R16.2, R19.1
unnamed: Q3.4 (G), R17.2, R20.1
unnamed: Q4.4 (G), R21.2, R24.1
unnamed: Q5.4 (G), R22.2, R25.1
unnamed: Q6.4 (G), R23.2, R26.1
OPAMP1_VINM: C35.2, R39.1; also elsewhere on the board
OPAMP1_VINP: R32.2, R33.1, R38.1; also elsewhere on the board
OPAMP1_VOUT: C35.1; also elsewhere on the board
OPAMP2_VINM: C34.2, R40.1; also elsewhere on the board
OPAMP2_VINP: R31.2, R34.1, R37.1; also elsewhere on the board
OPAMP2_VOUT: C34.1; also elsewhere on the board
OPAMP3_VINM: C33.2, R41.1; also elsewhere on the board
OPAMP3_VINP: R30.2, R35.1, R36.1; also elsewhere on the board
OPAMP3_VOUT: C33.1; also elsewhere on the board
OUT1: C17.2, Q1.1 (S), Q1.2 (S), Q1.3 (S), Q4.5 (D), R18.2; also elsewhere on the board
OUT2: C18.2, Q2.1 (S), Q2.2 (S), Q2.3 (S), Q5.5 (D), R19.2; also elsewhere on the board
OUT3: C19.2, Q3.1 (S), Q3.2 (S), Q3.3 (S), Q6.5 (D), R20.2; also elsewhere on the board
SHUNT1+: Q4.1 (S), Q4.2 (S), Q4.3 (S), R24.2, R27.1, R33.2
SHUNT1-: C20.2, C21.2, C22.2, C23.2, C24.2, C25.2, C26.2, C27.2, C28.2, C29.2, C30.2, C31.2, C32.2, D4.2 (A), R27.2, R28.2, R29.2, R39.2, R40.2, R41.2; also elsewhere on the board
SHUNT2+: Q5.1 (S), Q5.2 (S), Q5.3 (S), R25.2, R28.1, R34.2
SHUNT3+: Q6.1 (S), Q6.2 (S), Q6.3 (S), R26.2, R29.1, R35.2
VDDA: R30.1, R31.1, R32.1; also elsewhere on the board

Notes on the sheet:
4.7pF
10kΩ
MOSFET Specification ・Vgs=1.7V ・Qg=5.8nC@4.5V ・Rds=6.9mΩ ・Tr=Typ.5.6ns/Tf=Typ.11ns ・Rg=1.7Ω
ブートストラップコンデンサ充電時間：t_boot=5.8nC/((8V-0.5V) / 200Ω)=Max.160ns PWM最小パルス幅：t_LOW=Min.200ns@20kHz/8bitPWM
3Phase Half-Bridge
150kΩ
f_cutoff=100kHz
Current Sensing
Gate Driver Specification ・Rpmos=3.7Ω/Rnmos=1.6Ω ・Igate=Max.1000mA ・Vcc=8~15V
※SMDは1608/0402を基本とする 但しBasic優先
※指示なきコンデンサは耐圧6.3V以上
AN5306 Application note Operational Amplifier (OPAMP) usage in STM32G4 Series
Design Target ・Tr/Tf=20ns ・Igate=290mA Result ・Rgate=33Ω ・Ion=208mA@8V/391mA@15V ・Ioff=220mA@8V/413mA@15V ・Tr,Tf=15,13ns@8V/8,7ns@15V
Circuit Protection & Anti-Back EMF

Board: 4 copper layers, 61.0 x 61.0 mm, 124 parts (0 on the bottom side), 77 nets.
